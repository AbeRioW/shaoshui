# Keil uVision project dizuo.uvproj, settings and files
target dizuo (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: dizuo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\bsp
  group Source
    ./bsp/: dizuo.c oled.c ds18b20.c
